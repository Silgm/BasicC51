# Keil uVision project BasicC51.uvproj, settings and files
target Main (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: BasicC51 +hex
  c flags: Optimize=8
  link misc: REMOVEUNUSED
  group Startup
    ./: STARTUP.A51
  group Source
    ./: main.c delay.c gpio.c lcd1602.c i2csoft.c
  group Include
    ./: delay.h intdef.h gpio.h lcd1602.h binary.h i2csoft.h
